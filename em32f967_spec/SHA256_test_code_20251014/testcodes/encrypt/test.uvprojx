# Keil uVision project test.uvprojx, settings and files
target sha (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CMSDK_CM4 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output test_sha.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M4 USE_PRINT ITERATIONS=200 MSC_CLOCK EXPECTED_SYST, TEST_SHA
  c misc: -Ono_inline --no_inline --no_multifile -Oloopref
  c include: ..\..\software\cmsis\CMSIS\Include;..\..\software\cmsis\Device\ARM\CMSDK_CM4\Include;..\..\software\common\retarget;..\encrypt
  memory RVCT4: ROM 0x10000000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_CMSDK_CM4.s
  group Application
    ./: main.c sha_test.c
  group System
    ./: SHA256.c uart.c gpio.c Retarget.c system.c
    ../../software/cmsis/Device/ARM/CMSDK_CM4/Source/: system_CMSDK_CM4.c
  group Mbedtls
    ./mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
software components: CMSIS:CORE 5.0.0
